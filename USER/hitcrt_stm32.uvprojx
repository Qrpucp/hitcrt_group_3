# Keil uVision project hitcrt_stm32.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hitcrt_stm32
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;.\MAIN;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\Type;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\PWM;..\HARDWARE\USART;..\HARDWARE\DMA;..\HARDWARE\CAN;..\HARDWARE\PID;..\HARDWARE\OS;..\USER;.\TASK;..\RTOS;..\HARDWARE\TIM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_can.c
  group HANDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/USART/: usart.c retarget.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/TIM/: tim.c
  group USR
    ./: system_stm32f4xx.c stm32f4xx_it.c
    ./MAIN/: main.c
    ./TASK/: task.c
